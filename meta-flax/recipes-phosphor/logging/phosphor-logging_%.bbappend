FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-default-sel-enabled-when-globalenables-missing.patch"
