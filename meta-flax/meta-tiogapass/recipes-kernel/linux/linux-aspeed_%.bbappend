FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Increased-flash-chip-size.patch"
SRC_URI += "file://0002-enable-vuart-for-host-console.patch"

